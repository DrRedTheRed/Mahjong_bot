# Keil uVision project YH-KSTM32.uvprojx, settings and files
target YH_Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: YH-KSTM32 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\inc;..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\SRC;..\USER\includes
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: main.c stm32f10x_it.c app_gpio.c app_uart.c app_ps2.c app_sensor.c
  group SRC
    ../SRC/rcc/: y_rcc.c
    ../SRC/led/: y_led.c
    ../SRC/delay/: y_delay.c
    ../SRC/timer/: y_timer.c
    ../SRC/beep/: y_beep.c
    ../SRC/key/: y_key.c
    ../SRC/usart/: y_usart.c
    ../SRC/flash/: y_flash.c
    ../SRC/ps2/: y_ps2.c
    ../SRC/servo/: y_servo.c
    ../SRC/global/: y_global.c
    ../SRC/kinematics/: y_kinematics.c
    ../SRC/soft_i2c/: y_soft_i2c.c
    ../SRC/tcs34725/: y_tcs34725.c
    ../SRC/ws2812b/: y_ws2812b.c
    ../SRC/sensor/: y_sensor.c
  group Libraries
    ../Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../CMSIS/Startup/: startup_stm32f10x_md.s
